FILESEXTRAPATHS:prepend:= "${THISDIR}/${BPN}:"
