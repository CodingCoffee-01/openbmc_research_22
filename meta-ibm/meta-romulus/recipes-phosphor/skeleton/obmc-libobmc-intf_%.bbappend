FILESEXTRAPATHS:prepend:= "${THISDIR}/${PN}:"
