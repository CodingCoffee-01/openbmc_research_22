RDEPENDS:${PN}-extras:append:= " webui-vue"
addtask do_debug_info before do_fetch
