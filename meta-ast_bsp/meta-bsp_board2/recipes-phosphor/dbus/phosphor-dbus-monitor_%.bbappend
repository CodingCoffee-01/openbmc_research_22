FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
addtask do_debug_info before do_fetch
